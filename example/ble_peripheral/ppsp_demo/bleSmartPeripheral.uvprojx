# Keil uVision project bleSmartPeripheral.uvprojx, settings and files
target Smart BLE Peripheral (ARM-ADS)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.4.2.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: bleSmartPeripheral
  AfterMake: fromelf.exe --bin -o  ./bin  ./Objects/bleSmartPeripheral.axf
  AfterMake: fromelf.exe .\Objects\bleSmartPeripheral.axf --i32combined --output .\bin\bleSmartPeripheral.hex
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: CFG_CP  CFG_QFN32 MTU_SIZE=247  HOST_CONFIG=4 HCI_TL_NONE=1 OSAL_CBTIMER_NUM_TASKS=1 DEF_GAPBOND_MGR_ENABLE=0 CFG_SLEEP_MODE=PWR_MODE_SLEEP DEBUG_INFO=1 PHY_MCU_TYPE=MCU_BUMBEE_M0 USE_FS=0 MAX_NUM_LL_CONN=1
  c misc: -DADV_NCONN_CFG=0x01  -DADV_CONN_CFG=0x02  -DSCAN_CFG=0x04   -DINIT_CFG=0x08   -DBROADCASTER_CFG=0x01 -DOBSERVER_CFG=0x02  -DPERIPHERAL_CFG=0x04  -DCENTRAL_CFG=0x08   -DHOST_CONFIG=0x4
  c include: ..\..\..\components\inc;..\..\..\components\arch\cm0;..\..\..\components\osal\include;..\..\..\components\ble\include;..\..\..\components\ble\controller;..\..\..\components\ble\hci;..\..\..\components\ble\host;..\..\..\components\profiles\Roles;..\..\..\components\profiles\DevInfo;..\..\..\components\profiles\SimpleProfile;..\..\..\components\driver\uart;..\..\..\components\driver\log;..\..\..\components\driver\pwrmgr;..\..\..\components\driver\uart;..\..\..\components\driver\clock;..\..\..\components\driver\gpio;..\..\..\components\driver\adc;..\..\..\components\driver\pwm;..\..\..\components\driver\flash;..\..\..\components\driver\spi;..\..\..\components\driver\i2c;..\..\..\components\driver\watchdog;..\..\..\components\driver\timer;..\..\..\components\driver\kscan;..\..\..\lib;..\..\..\components\profiles\ppsp;..\..\..\components\libraries\tinycrypt-0.2.8\lib\include;.\Source;..\..\..\misc;..\..\..\components\libraries\fs
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x400
  memory RVCT9: RAM 0x1fff6000 size 0x2000
  scatter file: .\scatter_load.sct
  link misc: ..\..\..\misc\bb_rom_sym_m0.txt --keep=jump_table_base  --keep=global_config
  group arch
    ./Source/: main.c
  group profile
    ../../../components/profiles/DevInfo/: devinfoservice.c
    ../../../components/profiles/Roles/: gap.c gapbondmgr.c gapgattserver.c peripheral.c
    ../../../components/profiles/GATT/: gattservapp.c
    ./Source/: simpleGATTprofile.c
    ../../../components/profiles/ppsp/: list_slst.c core_queu.c ppsp_serv.c ppsp_impl.c
  group jump
    ../../../misc/: jump_table.c
  group app
    ./Source/: bleSmartPeripheral.c bleSmartPeripheral_Main.c OSAL_bleSmartPeripheral.c battery.c touch_key.c switch.c pwm_ctrl.c led.c
  group rf
    ../../../lib/: rf.lib
    ../../../lib/generate_ble_host_lib/Objects/: ble_host.lib
  group driver
    ../../../components/driver/clock/: clock.c
    ../../../components/driver/pwrmgr/: pwrmgr.c
    ../../../components/driver/gpio/: gpio.c
    ../../../components/driver/uart/: uart.c
    ../../../components/driver/log/: my_printf.c
    ../../../components/driver/adc/: adc.c
    ../../../components/driver/pwm/: pwm.c
    ../../../components/driver/flash/: flash.c
  group osal
    ../../../components/osal/snv/: osal_snv.c
  group TinyCryp
    ../../../components/libraries/tinycrypt-0.2.8/lib/source/: aes_decrypt.c aes_encrypt.c cbc_mode.c ccm_mode.c cmac_mode.c ctr_mode.c ctr_prng.c ecc.c ecc_dh.c ecc_dsa.c ecc_platform_specific.c hmac.c hmac_prng.c sha256.c utils.c
  group ::Device
    RTE/Device/ARMCM0/: startup_ARMCM0.s system_ARMCM0.c
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.1
