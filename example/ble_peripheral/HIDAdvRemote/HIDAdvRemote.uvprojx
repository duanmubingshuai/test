# Keil uVision project HIDAdvRemote.uvprojx, settings and files
target HidAdvRemote (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: HidAdvRemote
  AfterMake: fromelf.exe --bin -o  ./bin  ./Objects/HidAdvRemote.axf
  AfterMake: fromelf.exe .\Objects\HidAdvRemote.axf --i32combined --output .\bin\HidAdvRemote.hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CFG_CP CFG_QFN32 HOST_CONFIG=4 MTU_SIZE=247 HCI_TL_NONE=1 ENABLE_LOG_ROM_=0   DEBUG_INFO=1 DBG_ROM_MAIN=0 APP_CFG=0  OSALMEM_METRICS=0 PHY_MCU_TYPE=MCU_BUMBEE_M0  CFG_SLEEP_MODE=PWR_MODE_SLEEP DEBUG_INFO=1 HID_VOICE_SPEC USE_FS=1 MAX_NUM_LL_CONN=1 GATT_MAX_NUM_CONN = MAX_NUM_LL_CONN+1
  c misc: -DADV_NCONN_CFG=0x01   -DADV_CONN_CFG=0x02   -DSCAN_CFG=0x04    -DINIT_CFG=0x08   -DBROADCASTER_CFG=0x01 -DOBSERVER_CFG=0x02   -DPERIPHERAL_CFG=0x04   -DCENTRAL_CFG=0x08   -DHOST_CONFIG=0x4
  c include: ..\..\..\components\inc;..\..\..\components\arch\cm0;..\..\..\components\common;..\..\..\components\osal\include;..\..\..\components\ble\include;..\..\..\components\ble\hci;..\..\..\components\ble\host;..\..\..\components\ble\controller\include;..\..\..\components\profiles\DevInfo;..\..\..\components\profiles\GATT;..\..\..\components\profiles\SimpleProfile;..\..\..\components\profiles\Roles;..\..\..\components\profiles\HIDVoice;..\..\..\components\profiles\Batt;..\..\..\components\profiles\GATT;..\..\..\components\profiles\AudioProfile;..\..\..\components\profiles\ScanParam;..\..\..\components\driver\common;..\..\..\components\driver\log;..\..\..\components\driver\gpio;..\..\..\components\driver\pwrmgr;..\..\..\components\driver\uart;..\..\..\components\driver\clock;..\..\..\components\driver\flash;..\..\..\components\driver\adc;..\..\..\components\driver\spi;..\..\..\components\driver\i2c;..\..\..\components\driver\watchdog;..\..\..\components\driver\timer;..\..\..\components\driver\voice;..\..\..\components\driver\kscan;..\..\..\lib;.\Source;..\..\..\misc;..\..\..\components\ble\controller;..\..\..\components\libraries\fs
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x400
  memory RVCT9: RAM 0x1fff6000 size 0x2000
  scatter file: .\scatter_load.sct
  link misc: ..\..\..\misc\bb_rom_sym_m0.txt  --keep=jump_table_base  --keep=global_config
  group arch
    ./Source/: main.c
  group profile
    ../../../components/profiles/DevInfo/: devinfoservice.c
    ../../../components/profiles/GATT/: gattservapp.c
    ../../../components/profiles/Roles/: gap.c gapbondmgr.c gapgattserver.c peripheral.c
    ../../../components/profiles/Batt/: battservice.c
    ../../../components/profiles/ota_app/: ota_app_service.c
    ../../../components/profiles/AudioProfile/: AudioGATTprofile.c
    ../../../components/profiles/ScanParam/: scanparamservice.c
    ../../../components/profiles/HIDVoice/: hiddev.c hidkbdservice.c
  group jump
    ../../../misc/: jump_table.c
  group app
    ./Source/: hidkbd.c hidkbd_Main.c OSAL_hidkbd.c voice_task.c adpcm.c voice_circ_buff.c voice_data.c Voice_Queue.c hal_drivers.c hal_keyboard_matrix.c
  group lib
    ../../../lib/: rf.lib ble_host.lib
  group driver
    ../../../components/driver/gpio/: gpio.c
    ../../../components/driver/log/: my_printf.c
    ../../../components/driver/uart/: uart.c
    ../../../components/driver/pwrmgr/: pwrmgr.c
    ../../../components/driver/clock/: clock.c
    ../../../components/driver/flash/: flash.c
    ../../../components/driver/voice/: voice.c
    ../../../components/driver/kscan/: kscan.c
  group osal
    ../../../components/osal/snv/: osal_snv.c
  group fs
    ../../../components/libraries/fs/: fs.c
  group fs2
    ../../../components/libraries/fs2/: fs.c
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.1
