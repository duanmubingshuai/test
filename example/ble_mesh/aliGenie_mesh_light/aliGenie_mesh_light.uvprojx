# Keil uVision project aliGenie_mesh_light.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.0.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: aliGenie_mesh_light +hex
  AfterMake: fromelf.exe --bin -o  ./aliGenie_mesh_light.bin  ./Objects/aliGenie_mesh_light.axf
  AfterMake: fromelf -c -a -d -e -v -o aliGenie_mesh_light.asm ./Objects/aliGenie_mesh_light.axf
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CFG_CP, OSAL_CBTIMER_NUM_TASKS=1, MTU_SIZE=247 OSALMEM_METRICS=0 DEBUG_INFO=1 CFG_SLEEP_MODE = PWR_MODE_NO_SLEEP APP_CFG=0 ETHERMIND PHY_MCU_TYPE=MCU_BUMBEE_M0 USE_FS=0 MAX_NUM_LL_CONN=1 GATT_MAX_NUM_CONN = MAX_NUM_LL_CONN+1
  c misc: -DADV_NCONN_CFG=0x01  -DADV_CONN_CFG=0x02  -DSCAN_CFG=0x04   -DINIT_CFG=0x08   -DBROADCASTER_CFG=0x01 -DOBSERVER_CFG=0x02  -DPERIPHERAL_CFG=0x04  -DCENTRAL_CFG=0x08 -DHOST_CONFIG=0x0c
  c include: ..\..\..\components\inc;..\..\..\components\ble\controller\include;..\..\..\components\osal\include;..\..\..\components\common;..\..\..\components\ble\include;..\..\..\components\ble\hci;..\..\..\components\ble\host;..\..\..\components\Profiles\DevInfo;..\..\..\components\Profiles\SimpleProfile;..\..\..\components\Profiles\Roles;..\..\..\components\driver\common;..\..\..\components\driver\clock;..\..\..\components\driver\gpio;..\..\..\components\driver\pwrmgr;..\..\..\components\driver\log;..\..\..\components\driver\uart;..\..\..\components\driver\flash;..\..\..\components\driver\pwm;.\source;.\source\bleMesh;..\..\..\components\ethermind\external\crypto\aes;..\..\..\components\ethermind\mesh\export\include;..\..\..\components\ethermind\mesh\export\bearer;..\..\..\components\ethermind\mesh\export\platforms\ext;..\..\..\components\ethermind\osal\src\phyos;..\..\..\components\ethermind\platforms\meshlibs;..\..\..\components\ethermind\platforms\meshlibs\mesh;..\..\..\components\ethermind\platforms\meshlibs\interfaces\crypto;..\..\..\components\ethermind\platforms\meshlibs\interfaces\nvs;..\..\..\components\ethermind\utils\include;..\..\..\components\ethermind\mesh\export\cli;..\..\..\components\ethermind\mesh\export\cli\model\client;..\..\..\components\ethermind\mesh\export\appl;..\..\..\components\driver\pwrmgr;..\..\..\components\osal\snv;..\..\..\components\ethermind\external\crypto\asm_ecdh_p256;..\..\..\components\ethermind\external\crypto\sha256;..\..\..\components\ethermind\lib;..\..\..\components\profiles\aliGenie;..\..\..\components\ethermind\mesh\export\cbtimer;..\..\..\components\arch\cm0;..\..\..\misc;..\..\..\components\driver\timer;..\..\..\components\ble\controller;..\..\..\components\libraries\crc16;..\..\..\components\libraries\fs;..\..\..\components\driver\led_light
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x400
  memory RVCT5: ROM 0x1fff8000 size 0x1f40
  memory RVCT9: RAM 0x1fff6000 size 0x2000
  scatter file: .\scatter_load.sct
  link misc: ..\..\..\misc\bb_rom_sym_m0.txt  --keep=jump_table_base  --keep=global_config
  group arch
    ./source/: main.c
  group driver
    ../../../components/driver/pwm/: pwm.c
    ../../../components/driver/flash/: flash.c
    ../../../components/driver/clock/: clock.c
    ../../../components/driver/log/: my_printf.c
    ../../../components/driver/gpio/: gpio.c
    ../../../components/driver/uart/: uart.c
    ../../../components/driver/pwrmgr/: pwrmgr.c
    ../../../components/libraries/crc16/: crc16.c
  group profile
    ../../../components/profiles/DevInfo/: devinfoservice.c
    ../../../components/profiles/GATT/: gattservapp.c
    ../../../components/profiles/Roles/: peripheral.c gapgattserver.c gap.c observer.c central.c gapbondmgr.c
    ../../../components/profiles/Keys/: simplekeys.c
    ../../../components/profiles/SimpleProfile/: simpleGATTprofile_ota.c
  group jump
    ../../../misc/: jump_table.c
  group osal
    ../../../components/osal/snv/: osal_snv.c
  group blemesh
    ./source/bleMesh/: bleMesh.c bleMesh_Main.c OSAL_bleMesh.c
    ../../../components/ethermind/external/crypto/sha256/: sha256.c
    ../../../components/profiles/aliGenie/: ali_genie_profile.c
    ../../../components/ethermind/mesh/export/bearer/: blebrr.c
    ../../../components/driver/led_light/: led_light.c
  group ethermind
    ../../../components/ethermind/platforms/meshlibs/: EM_platform.c
    ../../../components/ethermind/external/crypto/aes/: aes.c aes-ccm.c
    ../../../components/ethermind/osal/src/phyos/: EM_debug.c EM_os.c EM_timer.c
    ../../../components/ethermind/platforms/meshlibs/mesh/: blebrr_pl.c mesh_services.c model_state_handler_pl.c mesh_clients.c
    ../../../components/ethermind/platforms/meshlibs/interfaces/crypto/: cry.c
    ../../../components/ethermind/mesh/export/bearer/: blebrr_gatt.c
    ../../../components/ethermind/mesh/export/platforms/ext/: MS_common_pl.c prov_pl.c
    ../../../components/ethermind/mesh/export/appl/: appl_prov.c appl_proxy.c
    ../../../components/ethermind/mesh/export/appl/model/server/generics/generic_battery_server/: appl_generic_battery_server.c
    ../../../components/ethermind/mesh/export/appl/model/server/generics/generic_default_transition_time_server/: appl_generic_default_transition_time_server.c
    ../../../components/ethermind/mesh/export/appl/model/server/generics/generic_level_server/: appl_generic_level_server.c
    ../../../components/ethermind/mesh/export/appl/model/server/generics/generic_location_server/: appl_generic_location_server.c
    ../../../components/ethermind/mesh/export/appl/model/server/generics/generic_onoff_server/: appl_generic_onoff_server.c
    ../../../components/ethermind/mesh/export/appl/model/server/generics/generic_power_level_server/: appl_generic_power_level_server.c
    ../../../components/ethermind/mesh/export/appl/model/server/generics/generic_power_onoff_server/: appl_generic_power_onoff_server.c
    ../../../components/ethermind/mesh/export/appl/model/server/generics/generic_property_server/: appl_generic_property_server.c
    ../../../components/ethermind/mesh/export/appl/model/server/lighting/light_ctl_server/: appl_light_ctl_server.c
    ../../../components/ethermind/mesh/export/appl/model/server/lighting/light_hsl_server/: appl_light_hsl_server.c
    ../../../components/ethermind/mesh/export/appl/model/server/lighting/light_lc_server/: appl_light_lc_server.c
    ../../../components/ethermind/mesh/export/appl/model/server/lighting/light_lightness_server/: appl_light_lightness_server.c
    ../../../components/ethermind/mesh/export/appl/model/server/lighting/light_xyl_server/: appl_light_xyl_server.c
    ../../../components/ethermind/mesh/export/appl/model/server/: appl_main_model_server.c appl_model_server_callback.c appl_model_server_state_handler.c
    ../../../components/ethermind/mesh/export/appl/model/server/health/: appl_health_server.c
    ../../../components/ethermind/mesh/export/appl/model/server/time_and_scenes/scene_server/: appl_scene_server.c
    ../../../components/ethermind/mesh/export/cbtimer/: EXT_cbtimer.c
  group cli
    ../../../components/ethermind/mesh/export/cli/: cli_main.c cli_brr.c cli_core.c cli_core_network.c cli_core_provision.c cli_core_proxy.c cli_core_transport.c cli_model.c cli_model_client.c cli_model_server.c cli_ps.c
    ../../../components/ethermind/mesh/export/cli/model/client/: cli_config_client.c cli_generic_battery_client.c cli_generic_default_transition_time_client.c cli_generic_level_client.c cli_generic_location_client.c cli_generic_onoff_client.c cli_generic_power_level_client.c cli_generic_power_onoff_client.c cli_generic_property_client.c cli_health_client.c cli_light_ctl_client.c cli_light_hsl_client.c cli_light_lc_client.c cli_light_lightness_client.c cli_light_xyl_client.c cli_scene_client.c
  group mesh_lib
    ../../../components/ethermind/lib/meshlibs/phyos/keil/: libethermind_mesh_core.lib libethermind_ecdh.lib libethermind_mesh_models.lib libethermind_utils.lib
  group samples
    ./source/bleMesh/: appl_sample_example_aliGenie_light.c
  group lib
    ../../../lib/: ble_host.lib rf.lib
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.1
