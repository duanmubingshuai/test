# Keil uVision project cliPeripheral.uvprojx, settings and files
target cliPeripheral (ARM-ADS)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.4.2.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: cliPeripheral +hex
  AfterMake: fromelf.exe --bin -o  ./bin/cliPeripheral.bin  ./Objects/cliPeripheral.axf
  AfterMake: fromelf -c -a -d -e -v -o ./bin/cliPeripheral.asm ./Objects/cliPeripheral.axf
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: CFG_CP HCI_TL_NONE=1 OSALMEM_METRICS=0 PHY_MCU_TYPE=MCU_BUMBEE_M0 MAIN_HAS_NOARGC MAIN_HAS_NORETURN DEBUG_INFO=1 CFG_SLEEP_MODE=PWR_MODE_NO_SLEEP
  c misc: -DADV_NCONN_CFG=0x01  -DADV_CONN_CFG=0x02  -DSCAN_CFG=0x04   -DINIT_CFG=0x08   -DBROADCASTER_CFG=0x01 -DOBSERVER_CFG=0x02  -DPERIPHERAL_CFG=0x04  -DCENTRAL_CFG=0x08 -DHOST_CONFIG=0xc
  c include: ..\..\..\components\inc;.\source;..\..\..\components\driver\clock;..\..\..\components\driver\gpio;..\..\..\components\arch\cm0;..\..\..\components\ble\include;..\..\..\components\ble\controller;..\..\..\components\ble\hci;..\..\..\components\ble\host;..\..\..\components\libraries\secure;..\..\..\components\osal\include;..\..\..\misc;..\..\..\components\driver\uart;..\..\..\components\driver\log;..\..\..\components\driver\adc;..\..\..\components\driver\pwrmgr;..\..\..\components\driver\timer;..\..\..\components\driver\spi;..\..\..\components\libraries\cliface;..\..\..\components\driver\pwm;..\..\..\components\driver\kscan;..\..\..\components\driver\dma;..\..\..\components\driver\flash;..\..\..\components\driver\spiflash
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x400
  memory RVCT9: RAM 0x1fff1000 size 0x3800
  scatter file: .\cliPeripheral.sct
  link misc: ..\..\..\misc\bb_rom_sym_m0.txt  --keep=jump_table_base  --keep=global_config
  group main
    ./source/: cliPeripheral.c cliPeripheral_Main.c main.c OSAL_cliPeripheral.c
  group driver
    ../../../components/driver/clock/: clock.c
    ../../../components/driver/gpio/: gpio.c
    ../../../components/driver/log/: my_printf.c
    ../../../components/driver/uart/: uart.c
    ../../../components/driver/pwrmgr/: pwrmgr.c
    ../../../components/driver/timer/: timer.c
    ../../../components/driver/pwm/: pwm.c
    ../../../components/driver/kscan/: kscan.c
    ../../../components/driver/dma/: dma.c
    ../../../components/driver/spi/: spi.c
    ../../../components/driver/flash/: flash.c
    ../../../components/driver/spiflash/: spiflash.c
  group jump
    ../../../misc/: jump_table.c
  group rf
    ../../../lib/: rf.lib
  group coremark
    ../../../components/coremark/: core_list_join.c core_main.c core_matrix.c core_portme.c core_state.c core_util.c
  group cli
    ../../../components/libraries/cliface/: cliface.c
  group ::Device
    RTE/Device/ARMCM0/: startup_ARMCM0.s system_ARMCM0.c
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.1
