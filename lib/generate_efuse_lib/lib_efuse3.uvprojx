# Keil uVision project lib_efuse3.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: lib_efuse3 (library)
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CFG_CP DEBUG_INFO=0 MTU_SIZE=247 PHY_MCU_TYPE=MCU_BUMBEE_M0
  c misc: -DADV_NCONN_CFG=0x01   -DADV_CONN_CFG=0x02   -DSCAN_CFG=0x04    -DINIT_CFG=0x08   -DBROADCASTER_CFG=0x01 -DOBSERVER_CFG=0x02   -DPERIPHERAL_CFG=0x04   -DCENTRAL_CFG=0x08   -DHOST_CONFIG=0x4
  c include: ..\..\components\inc;..\..\components\arch\cm0;..\..\components\osal\include;..\..\components\driver\gpio;..\..\components\driver\uart;..\..\components\driver\log;..\..\components\driver\flash;..\..\components\driver\clock;..\..\components\driver\timer;..\..\components\ble\hci;..\..\components\ble\host;..\..\components\ble\controller;..\..\components\ble\include;..\..\misc;.\source;..\include;..\..\lib\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: ..\..\..\misc\bb_rom_sym_m0.txt
  group efuse3
    ./source/: lib_efuse3.c
software components: CMSIS:CORE 5.4.0
