# Keil uVision project aoxEst.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.4.2.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: aoxEst.lib (library)
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: CFG_CP DEBUG_INFO=0 PHY_MCU_TYPE=MCU_BUMBEE_M0
  c misc: -DADV_NCONN_CFG=0x01   -DADV_CONN_CFG=0x02   -DSCAN_CFG=0x04    -DINIT_CFG=0x08   -DBROADCASTER_CFG=0x01 -DOBSERVER_CFG=0x02   -DPERIPHERAL_CFG=0x04   -DCENTRAL_CFG=0x08   -DHOST_CONFIG=0x4
  c include: ..\..\components\inc;..\..\misc;.\source;..\..\components\aoxEst;..\..\components\driver\log;..\..\components\driver\uart;..\..\components\driver\gpio;..\..\components\arch\cm0;..\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: ..\..\..\misc\bb_rom_sym_m0.txt
  group aox
    ../../components/aoxEst/src/: aoaComFun.c aoaEstAlgo.c
software components: CMSIS:CORE 3.40.0
