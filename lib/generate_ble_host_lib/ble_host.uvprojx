# Keil uVision project ble_host.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: ble_host (library)
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: _RTE_ CFG_CP DEBUG_INFO=0 PHY_MCU_TYPE=MCU_BUMBEE_M0 MTU_SIZE=247
  c misc: -DADV_NCONN_CFG=0x01   -DADV_CONN_CFG=0x02   -DSCAN_CFG=0x04    -DINIT_CFG=0x08   -DBROADCASTER_CFG=0x01 -DOBSERVER_CFG=0x02   -DPERIPHERAL_CFG=0x04   -DCENTRAL_CFG=0x08   -DHOST_CONFIG=0xC
  c include: ..\..\components\inc;..\..\components\arch\cm0;..\..\components\osal\include;..\..\components\driver\gpio;..\..\components\driver\uart;..\..\components\driver\log;..\..\components\driver\flash;..\..\components\driver\clock;..\..\components\driver\timer;..\..\components\ble\hci;..\..\components\ble\host;..\..\components\ble\controller;..\..\components\ble\include;..\..\misc;.\source;..\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: ..\..\..\misc\bb_rom_sym_m0.txt
  group HOST
    ../../components/ble_src/host/: att_client.c att_server.c att_util.c gap_centdevmgr.c gap_centlinkmgr.c gap_configmgr.c gap_devmgr.c gap_linkmgr.c gap_peridevmgr.c gap_perilinkmgr.c gap_simpletask.c gap_task.c gatt_client.c gatt_server.c gatt_task.c gatt_uuid.c l2cap_if.c l2cap_task.c l2cap_util.c linkdb.c sm_intpairing.c sm_mgr.c sm_pairing.c sm_rsppairing.c sm_task.c smp.c
software components: CMSIS:CORE 3.40.0
